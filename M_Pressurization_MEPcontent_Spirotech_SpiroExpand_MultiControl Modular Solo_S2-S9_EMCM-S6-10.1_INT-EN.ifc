Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Pressurization_MEPcontent_Spirotech_SpiroExpand_MultiControl Modular Solo_S2-S9_EMCM-S6-10.1_INT-EN.ifc
Time: 2025-08-05T18:22:40+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcBuildingElementProxy: M_Pressurization_MEPcontent_Spirotech_SpiroExpand_MultiControl Modular Solo_S2-S9_INT-EN:EMCM-S6-10.1, M_Pressurization_MEPcontent_Spirotech_SpiroExpand_MultiControl Modular Solo_S2-S9_INT-EN:EMCM-S6-10.1:1837190
In: F00
Type - Material: Color RGB 181-166-066, Color RGB 200-000-000, Color RGB 200-200-200 (2), Color RGB 040-040-040 (2), Color RGB 182-182-182, Color RGB 115-115-115, Color RGB 255-255-255, Color RAL 1003, Color RGB 055-055-055
Type - Other - Category: Mechanical Equipment; Bottom Plate: 474 mm; C: 452.35 mm; D: 1180 mm; E: 630 mm; F: 1040 mm; Family Name: M_Pressurization_MEPcontent_Spirotech_SpiroExpand_MultiControl Modular Solo_S2-S9_INT-EN; Flange: no; Front Pump: yes; G: 180 mm; Height to Rectangle: 88 mm; I: 115 mm; J: 110 mm; Middle Plate: 255 mm; Overflow Pipe Length: 394 mm; Overflow Pipe Nominal: 25.4 mm; Overflow Pipe Radius: 16.85 mm; Pipe Angle: 0 deg; Pipe Depth: 69 mm; Pipe Length: 577.6 mm; Pressure Pipe Nominal: 38.1 mm; Pressure Pipe Radius: 24.15 mm; Pump Height: 451.5 mm; Rear Pump: no; Rectangle Depth: 44 mm; Rectangle Height: 103 mm; Rectangle Width: 145 mm; S7-S9: no; Suction Pipe Nominal: 31.75 mm; Suction Pipe Radius: 21.2 mm; Top Part of Pump Height: 296 mm; Unit Depth: 720 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 835 mm; Height: 1360 mm; Overflow Diameter: 25.4 mm; Pressure Diameter: 38.1 mm; Refill Diameter: 12.7 mm; Suction Diameter: 31.75 mm; Use Nominal Diameter: yes; Width: 685 mm
Type - Electrical Engineering - Voltage: 400 V
Type - Electrical - Loads - Power: 2400 W
Type - Identity Data - Article Description: MultiControl Modular Solo6 - 10.1 bar; Article Type: EMCM-S6-10.1; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: MultiControl Modular Solo6 - 10.1 bar; EMCS Version: 5.0; ETIM Article Class: EC010260; Family Version: 12.24; GLN: 8717811000007; GTIN: 8717811042472; Manufacturer: Spirotech; Manufacturer Art. No.: EMCM-S6-10.1; Manufacturer URL: https://www.spirotech.com/8717811042472; MEPcontent Class: VACUUM_DEGASSER; Model: EMCM-S6-10.1; OmniClass Number: 23.75.50.11.14.14; OmniClass Title: Deaerators; Product Line: Spirotech; Revit Version: 2023; Type Name: EMCM-S6-10.1; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 040-040-040; Blue: Color RGB 000-100-200; Dark Grey: Color RGB 115-115-115; Grey: Color RGB 200-200-200; Light Black: Color RGB 055-055-055; Red: Color RGB 200-000-000; White: Color RGB 255-255-255; Yellow: Color RAL 1003
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Material: Color RGB 181-166-066, Color RGB 200-000-000, Color RGB 200-200-200, Color RGB 040-040-040, Color RGB 182-182-182, Color RGB 115-115-115, Color RGB 255-255-255, Color RAL 1003, Color RGB 055-055-055
Pset_BuildingElementProxyCommon - Reference: EMCM-S6-10.1; IsExternal: no
Pset_EnvironmentalImpactIndicators - Reference: EMCM-S6-10.1
Other - Angle: 180 deg; Back Clearance Safe: 0 mm; Family: M_Pressurization_MEPcontent_Spirotech_SpiroExpand_MultiControl Modular Solo_S2-S9_INT-EN; Family and Type: M_Pressurization_MEPcontent_Spirotech_SpiroExpand_MultiControl Modular Solo_S2-S9_INT-EN: EMCM-S6-10.1; Front Clearance Safe: 500 mm; Left Clearance Safe: 500 mm; Left Side Pipe: 203 mm; Reference Line Length: 62 mm; Refill Angle: 503 mm; Right Clearance Safe: 500 mm; Right Side Pipe: 225.5 mm; Top Clearance Safe: 500 mm; Type: EMCM-S6-10.1; Type Id: 1837159
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 11.6784 m2; Volume: 0.213188 m3
Identity Data - Mark: 4
Mechanical - Flow In: 0 m3/s; Pressure Flow: 0 m3/s; Refill Flow: 0 m3/s; Suction Flow: 0 m3/s; System Classification: Undefined,Power
Phasing - Phase Created: 3. New Construction
Visibility - Back Clearance: 0 mm; Front Clearance: 500 mm; Left Clearance: 500 mm; Left Side Connection: yes; Right Clearance: 500 mm; Right Side Connection: no; Show Service Area: no; Top Clearance: 500 mm

# IfcDistributionPort (5)
Description: Flow
Name | FlowDirection | PredefinedType
OutPort_1837190_1 | SOURCE | PIPE
InPort_1837190_2 | SINK | PIPE
OutPort_1837190_3 | SOURCE | PIPE
InPort_1837190_4 | SINK | PIPE
Port_1837190_5 | SOURCEANDSINK | CABLE | SystemType: ELECTRICAL
